# Keil uVision project miniproject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: miniproject +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s LCD_defines.h LCD.c LCD.h types.h defines.h delay.c delay.h kpm.c kpm_defines.h kpm.h rtc_defines.h rtc.c rtc.h main.c interrupt_defines.h interrupt.h interrupt.c project.c project.h
